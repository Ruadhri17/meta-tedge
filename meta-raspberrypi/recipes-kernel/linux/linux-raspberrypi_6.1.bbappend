FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://netfilter.cfg"
