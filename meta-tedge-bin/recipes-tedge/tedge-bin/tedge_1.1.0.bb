# Architecture variables
ARCH_REPO_CHANNEL = "release"
ARCH_VERSION = "1.1.0"
SRC_URI[aarch64.md5sum] = "b8b9941cdf026cfde9a650c06cd12a9e"
SRC_URI[armv6.md5sum] = "e673ec9de42b59cfe2cdba2aa7492012"
SRC_URI[armv7.md5sum] = "d67d2e98da8f627bfa321655022cd769"
SRC_URI[x86_64.md5sum] = "fc86e95c1d75a9a715d768ceb649e070"

require tedge.inc
