# Architecture variables
ARCH_REPO_CHANNEL = "release"
ARCH_VERSION = "1.1.1"
SRC_URI[aarch64.md5sum] = "166c14c7e101b7ffd0d6d9e0332239f5"
SRC_URI[armv6.md5sum] = "fa368894f6c0c18affc932eb7bfe4460"
SRC_URI[armv7.md5sum] = "ccf738b4a27505903c179263c8d77458"
SRC_URI[x86_64.md5sum] = "64f5e3a865ce0cdb6aea4c2083049205"

require tedge.inc
