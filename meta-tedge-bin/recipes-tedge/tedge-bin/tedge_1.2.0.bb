# Architecture variables
ARCH_REPO_CHANNEL = "release"
ARCH_VERSION = "1.2.0"
SRC_URI[aarch64.md5sum] = "334cd74429ca70c9fa0ee67db6eb5f1f"
SRC_URI[armv6.md5sum] = "7f3027bb743a2e8663219d7b8912bb5a"
SRC_URI[armv7.md5sum] = "e3005e98131783f11729ef3f08dec141"
SRC_URI[x86_64.md5sum] = "dcf8c5d463a900f445079c12a0df3f0e"

require tedge.inc
